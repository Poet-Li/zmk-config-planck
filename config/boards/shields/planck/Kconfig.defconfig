## config/boards/shields/planck/Kconfig.defconfig
```kconfig
if SHIELD_PLANCK
            
config ZMK_KEYBOARD_NAME
    default "PLANCK"

endif
```
